# Keil uVision project STM32F411CEU6_SPL.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411CEU6_SPL
  AfterMake: ..\07_QBuildViewer\keil-build-viewer.exe
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\02_Core\Inc;..\02_Core\Startup;..\02_Core\Interrupt;..\02_Core\Entry;..\02_Core\Peripherals\UART;..\02_Core\Peripherals\SPI;..\02_Core\Peripherals\Flash;..\02_Core\Peripherals\Watchdog;..\02_Core\Time;..\01_Drivers\CMSIS;..\01_Drivers\STM32F4xx_StdPeriph_Driver\inc;..\03_BSP\Key;..\03_BSP\LED;..\03_BSP\W25QXX;..\03_BSP\AT24Cxx;..\04_Middlewares_User\SEGGER_RTT;..\04_Middlewares_User\EasyLogger\inc;..\04_Middlewares_User\EasyLogger\debug;..\04_Middlewares_User\Ymodem;..\04_Middlewares_User\Algorithms\AES;..\04_Middlewares_User\CRC\include;..\04_Middlewares_User\SFUD;..\04_Middlewares_User\SFUD\inc;..\05_Business\Bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\bootloader_noinit.sct
  group 01_Drivers
    ../01_Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_spi.c stm32f4xx_iwdg.c
  group 02_Core_Startup
    ../02_Core/Startup/: system_stm32f4xx.c startup_stm32f411xe.s
  group 02_Core_Interrupt
    ../02_Core/Interrupt/: stm32f4xx_it.c
  group 02_Core_Peripherals
    ../02_Core/Peripherals/UART/: usart.c
    ../02_Core/Peripherals/SPI/: spi.c
    ../02_Core/Peripherals/Flash/: flash.c
    ../02_Core/Peripherals/Watchdog/: iwdg.c
  group 02_Core_Time
    ../02_Core/Time/: delay.c
  group 02_Core_Entry
    ../02_Core/Entry/: main.c
  group 03_BSP
    ../03_BSP/Key/: key.c
    ../03_BSP/LED/: led.c
    ../03_BSP/AT24Cxx/: iic.c at24cxx.c
    ../03_BSP/W25QXX/: w25qxx.c w25qxx_handler.c
  group 04_Middlewares_EasyLogger
    ../04_Middlewares_User/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h
    ../04_Middlewares_User/EasyLogger/port/: elog_port.c
    ../04_Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../04_Middlewares_User/EasyLogger/debug/: debug.c
  group 04_Middlewares_Ymodem
    ../04_Middlewares_User/Ymodem/: ymodem.c common.c
  group 04_Middlewares_Algorithms
    ../04_Middlewares_User/Algorithms/AES/: aes.c
  group 04_Middlewares_CRC
    ../04_Middlewares_User/CRC/src/: crcccitt.c
  group 04_Middlewares_SFUD
    ../04_Middlewares_User/SFUD/src/: sfud.c sfud_sfdp.c
    ../04_Middlewares_User/SFUD/port/: sfud_port.c
    ../04_Middlewares_User/SFUD/: sfud_adapter.c
  group 05_Business
    ../05_Business/Bootloader/: bootloader.c
