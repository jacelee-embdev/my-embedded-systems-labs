# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411CEU6 +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output=".\Objects\STM32F411CEU6.bin" !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\Core\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares_User\SEGGER_RTT;..\Middlewares_User\EasyLogger\inc;..\Middlewares_User\Ymodem;..\Middlewares_User\EasyLogger\debug;..\Business\Init;..\BSP\AT24Cxx;..\BSP\W25Qxx;..\BSP\Key;..\BSP\LED;..\BSP\UART;..\Business\Status;..\Business\OTA;..\Middlewares_User\CRC\include;..\Middlewares_User\SFUD;..\Middlewares_User\SFUD\inc
  asm include: ..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01_Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group 02_Core_Startup
    ./: startup_stm32f411xe.s
    ../Core/Src/: system_stm32f4xx.c
  group 02_Core_Interrupt
    ../Core/Src/: stm32f4xx_it.c
  group 02_Core_Peripherals
    ../Core/Src/: gpio.c dma.c spi.c usart.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group 02_Core_Entry
    ../Core/Src/: main.c
  group 02_Core_RTOS
    ../Core/Src/: freertos.c
  group 03_BSP
    ../BSP/LED/: led.c
    ../BSP/Key/: key.c
    ../BSP/AT24Cxx/: iic.c at24cxx.c
    ../BSP/W25Qxx/: w25qxx.c w25qxx_handler.c
    ../BSP/UART/: uart_handler.c
  group 04_OS_FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group 04_Middlewares_EasyLogger
    ../Middlewares_User/SEGGER_RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Middlewares_User/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares_User/EasyLogger/port/: elog_port.c
    ../Middlewares_User/EasyLogger/debug/: debug.c
  group 04_Middlewares_Ymodem
    ../Middlewares_User/Ymodem/: common.c ymodem.c
  group 04_Middlewares_CRC
    ../Middlewares_User/CRC/src/: crcccitt.c
  group 04_Middlewares_SFUD
    ../Middlewares_User/SFUD/port/: sfud_port.c
    ../Middlewares_User/SFUD/src/: sfud_sfdp.c sfud.c
    ../Middlewares_User/SFUD/: sfud_adapter.c
  group 05_Business
    ../Business/Init/: os_init.c
    ../Business/Status/: app.c
    ../Business/OTA/: fw_update.c
software components: CMSIS:CORE 4.3.0
